# Keil uVision project JointBoardControl.uvprojx, settings and files
target JointBoardControl (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JointBoardControl +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__CC_ARM,ARM_MATH_CM4
  c include: .\chipHAL\inc;.\Main;..\Tool;.\stm_lib;.\stm_lib\CMSIS\Device\ST\STM32F4xx\Include;.\stm_lib\CMSIS\Include;.\stm_lib\STM32F4xx_StdPeriph_Driver\inc;.\boardHAL\inc;..\MoterVectorControl;..\MotorParam;..\MotionControl;..\JointMotionControl;..\App;.\CHAL\easyflash\inc;..\CANopen301\driver;..\CANopen301\inc\stm32;..\CANopen301\inc;..\CANopen402;.\signalTransform\inc;..\SensorTransform;.\debug\inc;.\param_config;.\init;..\Appllication\ForceSensor;..\Appllication\Epos4Servo;..\Appllication\communication;..\Appllication\JointBoardControl;..\Appllication\AngleSensor
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ./Main/: main.c global.c stm32f4xx_it.c debugNote.txt
  group Application
    ../Appllication/ForceSensor/: ThreeAxisForceTransform.c
    ../Appllication/Epos4Servo/: servo_Control.c read_write_SDO.c
    ../Appllication/JointBoardControl/: JointControl.c BreakControl.c MotionPathProcess.c HandSwitch.c
    ../Appllication/AngleSensor/: AngleSensor.c
  group CANOpenDriver
    ../CANopen301/driver/: OD_CallbackProcess.c TestSlave.c CANopenMaster.c
    ../CANopen301/src/: CanopenInit.c
  group CANopen 301
    ../CANopen301/src/: can.c emcy.c lifegrd.c nmtMaster.c nmtSlave.c objacces.c ObjectDictionary.c pdo.c sdo.c states.c sync.c timer.c can_data_send.c can_queue.c
  group MotionControl
    ./param_config/: robot_leg_param.h motor_param_EC60.h equipment_param.h
  group Tool
    ../Tool/: Umath.c UmathASM.s motion_queue.c
  group stmlib
    ./stm_lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f40_41xxx.s
    ./stm_lib/: STM32_Driver.lib
    ./stm_lib/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ./stm_lib/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_spi.c stm32f4xx_gpio.c stm32f4xx_rcc.c
  group HAL
    ./boardHAL/src/: boardHAL.c
    ./chipHAL/src/: chipHAL_buzzer.c chipHAL_GPIO.c chipHAL_TIM.C chipHAL_USART.c chipHAL_CAN.c chipHAL_IWDG.c
  group SignalTransform
    ./chipHAL/src/: chipHAL_delay.c
    ./signalTransform/src/: ST_getId.c
  group Debug
    ./debug/src/: hardware_debug.c logic_debug.c
