# Keil uVision project CANopen.uvprojx, settings and files
target CANpen (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CANopen +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\CANopen\inc;..\CANopen\inc\stm32;..\CANopen\hardware;..\HARDWARE\LED;..\HARDWARE\sys;..\HARDWARE\KEY;..\CANopen\01_Dictionary;..\CANopen\02_Communication;..\CANopen\03_MotorDriver;..\CANopen\04_Interface;..\MathTool;..\CANopen\05_Safety;..\CANopen\06_TEST
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c main.h
  group Interface
    ../CANopen/04_Interface/: sys_init.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_dma.c
  group CANopen
    ../CANopen/src/: dcf.c emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
  group Dictionary
    ../CANopen/01_Dictionary/: Master.c Master2.c Slaver.c
  group MotorDriver
    ../CANopen/03_MotorDriver/: timer7_action_timing.c EPOS_control_word.c motor_control.c
  group Communication
    ../CANopen/02_Communication/: dual_can.c timer2.c
  group MathTool
    ../MathTool/: mathtool.c
  group Safety
    ../CANopen/05_Safety/: Para_monitor.c
  group README
    ../: readme.txt
  group TEST
    ../CANopen/06_TEST/: key_test.c
